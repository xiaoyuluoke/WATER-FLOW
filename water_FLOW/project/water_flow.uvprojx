# Keil uVision project water_flow.uvprojx, settings and files
target water_flow (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: water_flow +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,water_flow
  c include: ..\main;..\component\delay;..\component\LED;..\component\sys;..\component\usart;..\STM32_lib\CORE;..\STM32_lib\inc;..\STM32_lib\user_layer;..\component\KEY;..\component\lcd_driver;..\component\gui;..\component\UI;..\component\RTC;..\component\FreeRTOS\Source\include;..\component\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\component\FreeRTOS;..\component\FreeRTOS\Source\portable\MemMang;..\component\FreeRTOS\Source\CMSIS_RTOS;..\component\STMFLASH;..\component\PWM_in
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STM32_lib
    ../STM32_lib/CORE/: core_cm3.c startup_stm32f10x_hd.s
    ../STM32_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../STM32_lib/user_layer/: stm32f10x_it.c system_stm32f10x.c
  group component
    ../component/delay/: delay.c
    ../component/LED/: led.c
    ../component/sys/: sys.c
    ../component/usart/: usart.c
    ../component/KEY/: key.c
    ../component/lcd_driver/: Lcd_Driver.c
    ../component/gui/: GUI.c
    ../component/UI/: UI.c
    ../component/RTC/: rtc.c
    ../component/STMFLASH/: stmflash.c
    ../component/PWM_in/: pwm_in.c
  group main
    ../main/: main.c
  group FreeRTOS
    ../component/FreeRTOS/Source/: list.c queue.c tasks.c croutine.c event_groups.c
    ../component/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../component/FreeRTOS/Source/portable/MemMang/: heap_4.c
